FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-build-pass-tag-CC-to-libtool.patch"

